options:
  parameters:
    author: LeoDJ
    generate_options: qt_gui
    id: enocean_erp1
    output_language: python
    title: EnOcean Receiver
  states: {}

blocks:
- name: a_bit_file_name
  id: variable
  parameters:
    value: f'recording/data_{time.strftime("%Y-%m-%dT%H-%M-%S")}.bin' if write_decoded_bits else "recording/dummy.bin"
  states: {}
- name: a_iq_file_name
  id: variable
  parameters:
    comment: needs to start with a, otherwise other variables are not defined?
    value: f'recording/raw_{time.strftime("%Y-%m-%dT%H-%M-%S")}_{self.freq/1e6}MHz_{self.samp_rate/1e6}MSps.iq' if write_raw_iq else "recording/dummy.iq"
  states: {}
- name: agc_attack
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 0, 1, 2
    label: Attack (10^x)
    start: '-20'
    step: '0.1'
    stop: '0'
    value: '-2.5'
  states: {}
- name: agc_decay
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 2, 1, 2
    label: Decay (10^x)
    start: '-20'
    step: '0.1'
    stop: '0'
    value: '-7'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      Center frequency of
      source or recorded file
      (will be used for tuning
      to the desired frequency)
    gui_hint: 0, 0, 1, 10
    label: Center Freq (MHz)
    start: '866.5'
    step: '0.001'
    stop: '871'
    value: '868.3'
  states: {}
- name: damping
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 10, 1, 2
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: decode
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 1,0,1,1
    label: Decoding
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868.3e6
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 8, 1, 2
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.22'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,2
    label: RF Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate/symbol_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.2e6
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 6, 1, 3
    label: Squelch (set just above nosie floor)
    start: '-120'
    step: '1'
    stop: '0'
    value: '-31'
  states: {}
- name: squelch_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 9, 1, 3
    label: Squelch Alpha (10^x)
    start: '-10'
    step: '0.1'
    stop: '0'
    value: '-4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 6, 1, 2
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.15'
  states: {}
- name: write_decoded_bits
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 1,1,1,1
    label: Write Decoded Bits
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: write_raw_iq
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 1,2,1,1
    label: Write Raw IQ
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: pow(10, agc_attack)
    comment: |-
      Set attack/decay, so it doesn't 
      slope the peaks during a packet,
      but high enough so it's fast enough
      to keep the packet peaks at around 1
    decay_rate: pow(10, agc_decay)
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '100'
    reference: '2'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: pow(10, squelch_alpha)
    comment: |-
      It's a bit touchy with the alpha value.
      Too low and it'll miss the first transition
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq*1e6-freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Center signal
      (remove DC)
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: a_bit_file_name
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: a_iq_file_name
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: recording/raw_2026-06-26T16-53-22_868.3MHz_3.2MSps.iq
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Shift input 
      signal frequency
      (tune to frequeny 
      besides center)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: write_decoded_bits
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: write_raw_iq
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: decode
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: .\2026-06-25_23-41-34_867883577Hz_baseband_cut.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '0000000000000000010101010110'
    tagname: SOF
    threshold: '1'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '100000000000000000'
    tagname: end
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      This step is very flaky for some reason.
      Play around with TED Gain and Loop BW
      until the bit pattern looks good and doesn't
      move around much
    damping: damping
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: ted_gain
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: erp1
  id: epy_module
  parameters:
    comment: EnOcean Radio Protocol 1 util
    source_code: "# this module will be imported in the into your flowgraph\r\nimport traceback\r\nimport numpy as np\r\n\r\npolynomial = 0x07\r\n\r\ndef crc8(data: bytes) -> int:\r\n    crc = 0x00\r\n\r\n    for byte in data:\r\n        crc ^= byte\r\n\r\n        for _ in range(8):\r\n            if crc & 0x80:\r\n                crc = (((crc << 1) & 0xFF) ^ polynomial)\r\n            else:\r\n                crc = (crc << 1) & 0xFF\r\n\r\n    return crc\r\n\r\ndef checksum(data: bytes) -> int:\r\n    sum = 0\r\n    for byte in data:\r\n        sum += (byte)\r\n        sum &= 0xFF\r\n    return sum\r\n\r\ndef decode12to8(bit_list):\r\n    try:\r\n        out_list = []\r\n        err = False\r\n        eof = None\r\n        b = 0\r\n\r\n        for i, bit in enumerate(bit_list):\r\n            bit_pos = i % 12\r\n            byte_pos = i//12\r\n            \r\n            if bit_pos <= 2:\r\n                b |= bit << (7 - bit_pos)\r\n            elif bit_pos == 3:\r\n                if bit == (b>>5 & 1):\r\n                    err = bit_pos\r\n            elif bit_pos <= 6:\r\n                b |= bit << (7 - bit_pos + 1)\r\n            elif bit_pos == 7:\r\n                if bit == (b>>2 & 1):\r\n                    err = bit_pos\r\n            elif bit_pos <= 9:\r\n                b |= bit << (7 - bit_pos + 2)\r\n            elif bit_pos == 10:\r\n                eof = bit\r\n            elif bit_pos == 11:\r\n                if bit == eof:\r\n                    err = bit_pos\r\n\r\n                decoded_byte = ~b & 0xFF\r\n                out_list.append(decoded_byte) # invert bits\r\n                b = 0\r\n\r\n                if not eof: # last byte reached (inverted)\r\n                    status_byte, checksum_byte = out_list[-2:]\r\n                    if status_byte & 0x80:  # CRC8 algorithm\r\n                        crc_checksum = crc8(out_list[:-1])\r\n                        # print(f\"Status: {status_byte:02X}, CheckByte: {checksum_byte:02X}, ChecksumCalc: {crc_checksum:02X}\")\r\n                        if crc_checksum != checksum_byte:\r\n                            err = 12\r\n                            # break\r\n                    else:                   # Sum algorithm\r\n                        sum = checksum(out_list[:-1])\r\n                        # print(f\"Status: {status_byte:02X}, CheckByte: {checksum_byte:02X}, ChecksumCalc: {sum:02X}\")\r\n                        if sum != checksum_byte:\r\n                            err = 12\r\n                            # break\r\n                    break\r\n\r\n        \r\n\r\n        print(' '.join(f'{int(x):02X}' for x in out_list) + (f\" Error {err}!\" if err else \"\") + (\" (Checksum)\" if err == 12 else \"\"))\r\n        if err:\r\n            out_list = []\r\n        return np.array(out_list)\r\n    except Exception:\r\n        traceback.print_exc()"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: symbol_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: symbol_rate/20
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    comment: |-
      Custom Python code to decode the 8-to-12 encoding 
      to actual bytes.
      Returns empty PDU, if decoding error is detected.
      (Bit error or wrong CRC)
      Currently only SOF variant 2 is tested.
    fn: 'lambda x: erp1.decode12to8(x)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_tags_to_pdu_x_0
  id: pdu_tags_to_pdu_x
  parameters:
    end_tag: end
    eob_alignment: '256'
    minoutbuf: '256'
    start_tag: SOF
    type: b
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 3, 0, 1, 6
    name: Shifted Input
    rate: '30'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 3, 6, 1, 6
    name: Squelch
    rate: '60'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 5, 6, 1, 6
    label1: Symbol Sync
    label2: Sliced & Tagged
    name: Symbol Sync Debug
    nconnections: '2'
    size: '256'
    srate: samp_rate
    tr_chan: '1'
    tr_delay: '5e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"SOF"'
    type: float
    ymax: '1.2'
    ymin: '-2.2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    gui_hint: 5, 0, 1, 6
    label1: Conditioned
    name: Conditioned Signal
    size: int(256*samp_per_sym)
    srate: samp_rate
    tr_delay: 5e-6*samp_per_sym
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: center_freq*1e6
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq*1e6
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: conditioned_signal
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tagged_bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: conditioned_signal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tagged_bits
  states: {}

connections:
- [analog_agc3_xx_0, '0', virtual_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_agc3_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_sink_x_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_const_vxx_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_selector_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_selector_0_0_0, '0', pdu_tags_to_pdu_x_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', virtual_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [pdu_pdu_lambda_0, pdu, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_selector_0, '0']
- [pdu_tags_to_pdu_x_0, pdus, pdu_pdu_lambda_0, pdu]
- [soapy_bladerf_source_0, '0', blocks_multiply_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_0, '0']
- [virtual_source_0, '0', blocks_selector_0_0, '0']
- [virtual_source_0_0, '0', blocks_selector_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
